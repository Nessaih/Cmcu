# Keil uVision project stm32f40x_project.uvprojx, settings and files
target project (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\App\inc;..\CMSIS\inc;..\Driver\inc;..\User\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOS_TASK\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/src/: usart1.c
  group Driver
    ../Driver/src/: Beep.c key.c led.c
  group CMSIS
    ../CMSIS/src/: system_stm32f4xx.c stm32f4xx_it.c
  group User
    ../User/src/: main.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
  group UCOSII_CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group UCOSII_CODE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm
  group UCOS_TASK
    ../UCOS_TASK/src/: start_task.c key_task.c beep_task.c led_task.c
