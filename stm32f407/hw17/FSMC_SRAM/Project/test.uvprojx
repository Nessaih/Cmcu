# Keil uVision project test.uvprojx, settings and files
target test (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\App\inc;..\CMSIS\inc;..\Driver\inc;..\USER\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/src/: usart1.c EXTI.c delay.c timer.c adc.c rtc.c iic.c spi.c
  group CMSIS
    ../CMSIS/src/: system_stm32f4xx.c stm32f4xx_it.c
  group Driver
    ../Driver/src/: led.c Beep.c key.c AT24Cxx.c flash.c sram.c
  group User
    ../USER/src/: main.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
