# Keil uVision project test.uvprojx, settings and files
target test (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\cmsis\inc;..\app\inc;..\driver\inc;..\user\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group uesr
    ../user/src/: main.c
  group cmsis
    ../cmsis/src/: system_stm32f4xx.c
  group driver
    ../driver/src/: led.c beep.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
