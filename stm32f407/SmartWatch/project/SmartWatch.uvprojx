# Keil uVision project SmartWatch.uvprojx, settings and files
target SmartWatch (ARM-ADS)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SmartWatch +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F411xE
  c include: ..\app\inc;..\cmsis\inc;..\driver\inc;..\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../user/src/: main.c menu.c
  group startup
    ../startup/: startup_stm32f411xe.s
  group app
    ../app/src/: usart.c delay.c spi.c iic.c rtc.c
  group driver
    ../driver/src/: led.c key.c oled_screen.c sht20.c motor.c hp6.c hp6_IIC.c mpu6050.c stepAlgorithm.c watchInfo.c bluetooth.c gpio.c
  group cmsis
    ../cmsis/src/: system_stm32f4xx.c
