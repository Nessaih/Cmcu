# Keil uVision project test.uvprojx, settings and files
target test (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\App\inc;..\CMSIS\inc;..\Driver\inc;..\USER\inc;..\UcosII\CONFIG;..\UcosII\CORE;..\UcosII\PORT;..\Ucos_Task\src;..\Ucos_Task\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/src/: USART.c
  group CMSIS
    ../CMSIS/src/: stm32f4xx_it.c system_stm32f4xx.c
  group Driver
    ../Driver/src/: led.c
  group User
    ../USER/src/: main.c
  group Startup
    ../Startup/: startup_stm32f40_41xxx.s
  group UcosII_CONFIG
    ../UcosII/CONFIG/: includes.h os_cfg.h
  group UcosII_CODE
    ../UcosII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UcosII_PORT
    ../UcosII/PORT/: os_cpu_a.asm os_cpu_c.c
  group Ucos_Task
    ../Ucos_Task/src/: Start_Task.c
