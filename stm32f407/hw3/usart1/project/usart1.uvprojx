# Keil uVision project usart1.uvprojx, settings and files
target usart1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usart1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx
  c include: ..\app\inc;..\cmsis\inc;..\driver\inc;..\user\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSISI
    ../cmsis/src/: system_stm32f4xx.c stm32f4xx_it.c
  group APP
    ../app/src/: usart1.c
  group startup
    ../startup/: startup_stm32f40_41xxx.s
  group user
    ../user/src/: main.c
